# Keil uVision project voiture_test.uvprojx, settings and files
target NUCLEO-F103RB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\lib\StdPeriph_Ex\inc;..\lib\Drivers_Car\inc;..\lib\Common;..\app;..\lib\SCADE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../app/: main.c manager.c
  group Drivers_Car
    ../lib/Drivers_Car/src/: battery.c can.c data_interface.c direction.c driver_callbacks.c frame_check.c front_motor.c hall_sensors.c init.c mirroring.c motors.c position_sensors.c rear_motors.c speed_sensors.c spi_comm.c system_time.c us_sensors.c
  group StdPeriph_Ex
    ../lib/StdPeriph_Ex/src/: adc.c debug.c dma.c exti.c gpio.c it_handlers.c nvic.c pwm.c spi.c systick.c tim.c tim_ic.c
  group Common
    ../lib/Common/: common_constants.h
  group StdPeriph
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group SCADE
    ../lib/SCADE/: checkThreshold.c kcg_consts.c kcg_types.c US_handler.c
target simu (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\lib\StdPeriph_Ex\inc;..\lib\Drivers_Car\inc;..\lib\Common;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
